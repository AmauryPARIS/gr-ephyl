<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>(T_bch+len(bs_slots)*(T_s+T_g)+T_p)/float(1000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.make_dict(), pmt.init_u8vector(1,[1]))</value></param>
<param><key>period</key><value>.01</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>ephyl_easy_upper</key>
<param><key>id</key><value>ephyl_easy_upper_0</value></param>
</block>
<block>
<key>hier_bs</key>
<param><key>id</key><value>hier_bs_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>exit_frame</key><value>1000</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>N</value></param>
<param><key>UHD</key><value>True</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>T_s</key><value>T_s</value></param>
</block>
<block>
<key>hier_sensor</key>
<param><key>id</key><value>hier_sensor_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>log</key><value>log</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>1</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>control</key><value>"0"</value></param>
<param><key>T_s</key><value>T_s</value></param>
</block>
<block>
<key>hier_sensor</key>
<param><key>id</key><value>hier_sensor_0_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>log</key><value>log</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>1</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>control</key><value>"2"</value></param>
<param><key>T_s</key><value>T_s</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random,string</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>pdus</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>hier_sensor_0_0</sink_block_id><source_key>pdus</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>hier_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_easy_upper_0</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>inst</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>ephyl_easy_upper_0</source_block_id><sink_block_id>hier_sensor_0_0</sink_block_id><source_key>inst</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>BCH</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>DL</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>ephyl_easy_upper_0</sink_block_id><source_key>feedback</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>hier_sensor_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_sensor_0_0</source_block_id><sink_block_id>ephyl_easy_upper_0</sink_block_id><source_key>feedback</source_key><sink_key>feedback</sink_key></connection>
</flow_graph>
