<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bs_multisn_multislot_dyn_ephyl_lora</value></param>
<param><key>description</key><value>Base station flowgraph for the multislot dynamic version of the gr ephyl project</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>BS flowgraph</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_1_ulcch</value></param>
<param><key>value</key><value>"tcp://" + str(sn_1_ip_addr) + ":" + str(port_ulcch_1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_2_ulcch</value></param>
<param><key>value</key><value>"tcp://" + str(sn_2_ip_addr) + ":" + str(port_ulcch_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_bs_feedback</value></param>
<param><key>value</key><value>"tcp://*:" + str(port_bs_feedback)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_bs_inst</value></param>
<param><key>value</key><value>"tcp://" + str(ip_decision_layer_addr) + ":" + str(port_bs_inst)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_dlcch</value></param>
<param><key>value</key><value>"tcp://*:" + str(port_dlcch)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_sync</value></param>
<param><key>value</key><value>"tcp://*:" + str(port_sync)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>value</key><value>range(S)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>(T_bch+len(bs_slots)*(T_s+T_g)+T_p)/float(1000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_dlcch</value></param>
<param><key>value</key><value>5600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_sync</value></param>
<param><key>value</key><value>5556</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_ulcch_1</value></param>
<param><key>value</key><value>5601</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_ulcch_2</value></param>
<param><key>value</key><value>5602</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(sample_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>int(samp_rate/1000 * (T_p + T_bch + (T_s + T_g) * len(bs_slots)))</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>hier_bs_lora_0.ephyl_bs_scheduler_0</value></param>
<param><key>function_args</key><value>self</value></param>
<param><key>function_name</key><value>set_top_block</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>S</value></param>
<param><key>label</key><value>Number of slot</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_sync</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Sync duration (ms)</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>slot</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>debug_log</value></param>
<param><key>label</key><value>log</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>hier_bs_lora</key>
<param><key>id</key><value>hier_bs_lora_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>lora_bw</key><value>int(lora_bw)</value></param>
<param><key>lora_crc</key><value>lora_crc</value></param>
<param><key>lora_cr</key><value>lora_cr</value></param>
<param><key>exit_frame</key><value>1000</value></param>
<param><key>log</key><value>debug_log</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>list_sensor</key><value>list_sensor</value></param>
<param><key>M</key><value>M</value></param>
<param><key>UHD</key><value>True</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>T_s</key><value>T_s</value></param>
<param><key>lora_sf</key><value>lora_sf</value></param>
<param><key>power_tresh_detection</key><value>power_tresh</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip_decision_layer_addr</value></param>
<param><key>label</key><value>IP/name of decision layer</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>list_sensor</value></param>
<param><key>label</key><value>List of sensors</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ABCD</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_bw</value></param>
<param><key>label</key><value>Bandwidth - LoRa</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_cr</value></param>
<param><key>label</key><value>Coding rate - LoRa [0-4]</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_crc</value></param>
<param><key>label</key><value>CRC</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_sf</value></param>
<param><key>label</key><value>Spreading factor - LoRa</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_bs_feedback</value></param>
<param><key>label</key><value>Port for BS feedback</value></param>
<param><key>value</key><value>5562</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_bs_inst</value></param>
<param><key>label</key><value>Port for BS instruction</value></param>
<param><key>value</key><value>5561</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>power_tresh</value></param>
<param><key>label</key><value>Power detection treshold</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sn_1_ip_addr</value></param>
<param><key>label</key><value>First sensor IP/Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>mnode4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sn_2_ip_addr</value></param>
<param><key>label</key><value>Second sensor IP/Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>mnode5</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>250e3</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>addr_sync</value></param>
<param><key>comment</key><value>Sync channel - BS to Sensors</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>addr_bs_feedback</value></param>
<param><key>comment</key><value>Feedback channel - BS to upper decision layer</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0_0</value></param>
<param><key>address</key><value>addr_dlcch</value></param>
<param><key>comment</key><value>Control channel - DLCCH from BS to sensors</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>addr_bs_inst</value></param>
<param><key>comment</key><value>Instructions channel - Decision layer to BS</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0_0</value></param>
<param><key>address</key><value>addr_1_ulcch</value></param>
<param><key>comment</key><value>Control channel - ULCCH from sensor 1 to BS</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0_0_0</value></param>
<param><key>address</key><value>addr_2_ulcch</value></param>
<param><key>comment</key><value>Control channel - ULCCH from sensor 2 to BS</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_short_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>hier_bs_lora_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_bs_lora_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>BCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_bs_lora_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>DL</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_bs_lora_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0</sink_block_id><source_key>DLCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_bs_lora_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_bs_lora_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_bs_lora_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>hier_bs_lora_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>hier_bs_lora_0</sink_block_id><source_key>out</source_key><sink_key>inst</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0_0</source_block_id><sink_block_id>hier_bs_lora_0</sink_block_id><source_key>out</source_key><sink_key>ULCCH</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0_0_0</source_block_id><sink_block_id>hier_bs_lora_0</sink_block_id><source_key>out</source_key><sink_key>ULCCH</sink_key></connection>
</flow_graph>
