<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>multisn_multislot_dyn_ephyl_lora</value></param>
<param><key>description</key><value>Sensor flowgraph for the multislot dynamic version of the gr ephyl project</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Multi-Sensor flowgraph</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_dlcch</value></param>
<param><key>value</key><value>str("tcp://" + str(ip_bs_addr) + ":" + str(port_dlcch))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_sn_feedback</value></param>
<param><key>value</key><value>str("tcp://*:" + str(port_sn_feedback))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_sn_inst</value></param>
<param><key>value</key><value>str("tcp://" + str(ip_decision_layer_addr) + ":" + str(port_sn_inst))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_sync</value></param>
<param><key>value</key><value>str("tcp://" + str(ip_bs_addr) + ":" + str(port_sync))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr_ulcch</value></param>
<param><key>value</key><value>str("tcp://*:" + str(port_ulcch))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>value</key><value>range(S)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>(T_bch+len(bs_slots)*(T_s+T_g)+T_p)/float(1000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>17</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>incr_port_sensor_ulcch</value></param>
<param><key>value</key><value>0 if list_sensor[0] == "A" else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_dlcch</value></param>
<param><key>value</key><value>5600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_sync</value></param>
<param><key>value</key><value>5556</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port_ulcch</value></param>
<param><key>value</key><value>5601 + incr_port_sensor_ulcch</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(sample_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_uhd</value></param>
<param><key>value</key><value>"packet_len_id"</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>hier_sensor_lora_0.ephyl_sn_scheduler_0_0</value></param>
<param><key>function_args</key><value>self</value></param>
<param><key>function_name</key><value>set_top_block</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>S</value></param>
<param><key>label</key><value>Number of slots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_sync</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Sync duration (ms)</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>debug_log</value></param>
<param><key>label</key><value>log</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>hier_sensor_lora</key>
<param><key>id</key><value>hier_sensor_lora_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>lora_bw</key><value>lora_bw</value></param>
<param><key>lora_crc</key><value>lora_crc</value></param>
<param><key>lora_cr</key><value>lora_cr</value></param>
<param><key>log</key><value>debug_log</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>UHD</key><value>True</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sn_id</key><value>list_sensor[0]</value></param>
<param><key>T_s</key><value>T_s</value></param>
<param><key>lora_sf</key><value>lora_sf</value></param>
<param><key>tag_len_id</key><value>tag_uhd</value></param>
</block>
<block>
<key>hier_sensor_lora</key>
<param><key>id</key><value>hier_sensor_lora_0_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>lora_bw</key><value>lora_bw</value></param>
<param><key>lora_crc</key><value>lora_crc</value></param>
<param><key>lora_cr</key><value>lora_cr</value></param>
<param><key>log</key><value>debug_log</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>UHD</key><value>True</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sn_id</key><value>list_sensor[1]</value></param>
<param><key>T_s</key><value>T_s</value></param>
<param><key>lora_sf</key><value>lora_sf</value></param>
<param><key>tag_len_id</key><value>tag_uhd</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip_bs_addr</value></param>
<param><key>label</key><value>IP/name of BS</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>mnode3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip_decision_layer_addr</value></param>
<param><key>label</key><value>IP/name of decision layer</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>list_sensor</value></param>
<param><key>label</key><value>List of sensors</value></param>
<param><key>value</key><value>["A","B"]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_bw</value></param>
<param><key>label</key><value>Bandwidth - LoRa</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_cr</value></param>
<param><key>label</key><value>Coding rate - LoRa [0-4]</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_crc</value></param>
<param><key>label</key><value>CRC</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_sf</value></param>
<param><key>label</key><value>Spreading factor - LoRa</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_sn_feedback</value></param>
<param><key>label</key><value>Port for SN feedback</value></param>
<param><key>value</key><value>5560</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_sn_inst</value></param>
<param><key>label</key><value>Port for SN instruction</value></param>
<param><key>value</key><value>5559</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>250e3</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value>tag_uhd</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>addr_sn_feedback</value></param>
<param><key>comment</key><value>Feedback channel - Sensor to upper decision layer</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>addr_ulcch</value></param>
<param><key>comment</key><value>Control channel - ULCCH from sensors to BS</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>addr_sn_inst</value></param>
<param><key>comment</key><value>Instruction channel - Upper decision layer to sensors</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>addr_sync</value></param>
<param><key>comment</key><value>Sync channel - BS to sensors</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_1</value></param>
<param><key>address</key><value>addr_dlcch</value></param>
<param><key>comment</key><value>Control channel - DLCCH from BS to sensors</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>ULCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>ULCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_lora_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>hier_sensor_lora_0</sink_block_id><source_key>out</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>hier_sensor_lora_0_0</sink_block_id><source_key>out</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>hier_sensor_lora_0</sink_block_id><source_key>out</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>hier_sensor_lora_0_0</sink_block_id><source_key>out</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_1</source_block_id><sink_block_id>hier_sensor_lora_0</sink_block_id><source_key>out</source_key><sink_key>DLCCH</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_1</source_block_id><sink_block_id>hier_sensor_lora_0_0</sink_block_id><source_key>out</source_key><sink_key>DLCCH</sink_key></connection>
</flow_graph>
