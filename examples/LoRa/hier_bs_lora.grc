<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_bs_lora</value></param>
<param><key>category</key><value>[ephyl]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LoRa BS Emulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>MTU*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79,109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Processing duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>UHD</value></param>
<param><key>label</key><value>Over the air</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>out_bs_sched</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(5)</value></param>
</block>
<block>
<key>ephyl_bs_scheduler</key>
<param><key>id</key><value>ephyl_bs_scheduler_0</value></param>
<param><key>bch_time</key><value>T_bch</value></param>
<param><key>exit_frame</key><value>exit_frame</value></param>
<param><key>log</key><value>log</value></param>
<param><key>guard_time</key><value>T_g</value></param>
<param><key>list_sensor</key><value>list_sensor</value></param>
<param><key>num_slots</key><value>len(bs_slots)</value></param>
<param><key>UHD</key><value>UHD</value></param>
<param><key>Proc_time</key><value>T_p</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
<param><key>Slot_time</key><value>T_s</value></param>
</block>
<block>
<key>ephyl_busy_tresh</key>
<param><key>id</key><value>ephyl_busy_tresh_0</value></param>
<param><key>log</key><value>log</value></param>
<param><key>tresh</key><value>power_tresh_detection</value></param>
</block>
<block>
<key>ephyl_msg_mux</key>
<param><key>id</key><value>ephyl_msg_mux_0</value></param>
<param><key>log</key><value>log</value></param>
<param><key>list_sensor</key><value>list_sensor</value></param>
<param><key>phy_option</key><value>2</value></param>
</block>
<block>
<key>ephyl_tag_2_msg</key>
<param><key>id</key><value>ephyl_tag_2_msg_0_0</value></param>
<param><key>wanted_tag</key><value>"PUSCH"</value></param>
</block>
<block>
<key>ephyl_tag_2_msg</key>
<param><key>id</key><value>ephyl_tag_2_msg_0_0_0</value></param>
<param><key>wanted_tag</key><value>"FRAME"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>exit_frame</value></param>
<param><key>label</key><value>Exit Frame</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>hier_lora_rx</key>
<param><key>id</key><value>hier_lora_rx_0</value></param>
<param><key>hist_avg</key><value>5</value></param>
<param><key>noise_elem</key><value>20</value></param>
<param><key>bw</key><value>lora_bw</value></param>
<param><key>cr</key><value>lora_cr</value></param>
<param><key>has_crc</key><value>lora_crc</value></param>
<param><key>impl_head</key><value>False</value></param>
<param><key>pay_len</key><value>32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>lora_sf</value></param>
<param><key>udp_rx_port</key><value>6790</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value>-0.128616616593872,	-0.212206590789194,	-0.180063263231421,	3.89817183251938e-17	,0.300105438719035	,0.636619772367581	,0.900316316157106,	1	,0.900316316157106,	0.636619772367581,	0.300105438719035,	3.89817183251938e-17,	-0.180063263231421,	-0.212206590789194,	-0.128616616593872</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>list_sensor</value></param>
<param><key>label</key><value>List of sensors</value></param>
<param><key>value</key><value>["A","B"]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>log</value></param>
<param><key>label</key><value>Generate log files</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_bw</value></param>
<param><key>label</key><value>Bandwidth - LoRa</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_cr</value></param>
<param><key>label</key><value>Coding rate - LoRa [0-4]</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_crc</value></param>
<param><key>label</key><value>CRC</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lora_sf</value></param>
<param><key>label</key><value>Spreading factor - LoRa</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>DL</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>BCH</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>DLCCH</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>feedback</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>input_frame_sync</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>UL</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>inst</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1_0</value></param>
<param><key>label</key><value>ULCCH</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>power_tresh_detection</value></param>
<param><key>label</key><value>Treshold value for power detection</value></param>
<param><key>value</key><value>-15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>DLCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>bcn</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>ephyl_busy_tresh_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>ephyl_tag_2_msg_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>ephyl_tag_2_msg_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>pad_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_busy_tresh_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>feedback</source_key><sink_key>detect</sink_key></connection>
<connection><source_block_id>ephyl_msg_mux_0</source_block_id><sink_block_id>pad_sink_0_0_0_0_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_msg_mux_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>final_msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_0_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>tag_msg</source_key><sink_key>slot_n</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_0_0_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>tag_msg</source_key><sink_key>frame_n</sink_key></connection>
<connection><source_block_id>hier_lora_rx_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>MSG</source_key><sink_key>data</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>hier_lora_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ephyl_bs_scheduler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ephyl_bs_scheduler_0</sink_block_id><source_key>out</source_key><sink_key>inst</sink_key></connection>
<connection><source_block_id>pad_source_1_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>out</source_key><sink_key>ULCCH</sink_key></connection>
</flow_graph>
