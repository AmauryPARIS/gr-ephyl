<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sn_0_macrl</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>(T_bch+len(bs_slots)*(T_s+T_g)+T_p)/float(1000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ar</value></param>
<param><key>label</key><value>Activation rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control</value></param>
<param><key>comment</key><value>Which slot to use</value></param>
<param><key>label</key><value>Control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>hier_sensor</key>
<param><key>id</key><value>hier_sensor_0</value></param>
<param><key>activation_rate</key><value>ar</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>log</key><value>log</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>1</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>control</key><value>control</value></param>
<param><key>T_s</key><value>T_s</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random,string</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>start_time</key><value>-1</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>PER 1</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://mnode33:5556</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>out</source_key><sink_key>DL</sink_key></connection>
</flow_graph>
