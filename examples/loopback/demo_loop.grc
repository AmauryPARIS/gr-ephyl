<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demo_loop</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bs_slots_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>bs_slots[:-4]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>debug_log</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>(T_bch+len(bs_slots)*(T_s+T_g)+T_p)/float(1000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2450e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Offset (Multiples of Sub-carrier spacing)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-.1</value></param>
<param><key>step</key><value>.00001</value></param>
<param><key>stop</key><value>.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>32</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Absolute Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>0.25</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>taps phase</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2*3.14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.995</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>1.005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_sync</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Sync duration (ms)</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.make_dict(), pmt.init_u8vector(1,[1]))</value></param>
<param><key>period</key><value>.01</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(1)</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>complex(np.cos(phase),np.sin(phase))</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control0</value></param>
<param><key>label</key><value>Control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>random</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control1</value></param>
<param><key>label</key><value>Control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>1:2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control2</value></param>
<param><key>label</key><value>Control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control3</value></param>
<param><key>label</key><value>Control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>ephyl_easy_upper</key>
<param><key>id</key><value>ephyl_easy_upper_0</value></param>
<param><key>BS</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>debug_log</value></param>
<param><key>list_sensor</key><value>list_sensor</value></param>
<param><key>list_slots</key><value>bs_slots</value></param>
</block>
<block>
<key>ephyl_easy_upper</key>
<param><key>id</key><value>ephyl_easy_upper_0_0</value></param>
<param><key>BS</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>debug_log</value></param>
<param><key>list_sensor</key><value>list_sensor</value></param>
<param><key>list_slots</key><value>bs_slots</value></param>
</block>
<block>
<key>hier_bs</key>
<param><key>id</key><value>hier_bs_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>exit_frame</key><value>600</value></param>
<param><key>debug_log</key><value>True</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>list_sensor</key><value>["A","B"]</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>N</value></param>
<param><key>UHD</key><value>False</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>T_s</key><value>T_s</value></param>
<param><key>power_tresh_detection</key><value>5</value></param>
</block>
<block>
<key>hier_sensor</key>
<param><key>id</key><value>hier_sensor_0</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>debug_log</key><value>True</value></param>
<param><key>log</key><value>True</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>1</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>id_0</key><value>"A"</value></param>
<param><key>control</key><value>control0</value></param>
<param><key>T_s</key><value>T_s</value></param>
</block>
<block>
<key>hier_sensor</key>
<param><key>id</key><value>hier_sensor_0_2</value></param>
<param><key>T_bch</key><value>T_bch</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>debug_log</key><value>True</value></param>
<param><key>log</key><value>True</value></param>
<param><key>T_g</key><value>T_g</value></param>
<param><key>M</key><value>M</value></param>
<param><key>N</key><value>1</value></param>
<param><key>T_p</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>id_0</key><value>"B"</value></param>
<param><key>control</key><value>control1</value></param>
<param><key>T_s</key><value>T_s</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random,string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>list_sensor</value></param>
<param><key>label</key><value>List of sensors</value></param>
<param><key>value</key><value>["A","B"]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>power_tresh_detect</value></param>
<param><key>label</key><value>Treshold value for power detection</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>control0</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>control1</value></param>
<param><key>marker2</key><value>8</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>control2</value></param>
<param><key>marker3</key><value>3</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>control3</value></param>
<param><key>marker4</key><value>2</value></param>
<param><key>name</key><value>Packet Error rate</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>PER</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>UL BS</value></param>
<param><key>name</key><value>BS IQ Frame</value></param>
<param><key>size</key><value>int(frame_len*samp_rate)/int(2*M*(1+cp_ratio))</value></param>
<param><key>srate</key><value>samp_rate/int(2*M*(1+cp_ratio))</value></param>
<param><key>tr_level</key><value>.9</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>BCH</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>400</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>UL BS</value></param>
<param><key>name</key><value>SN IQ Frame</value></param>
<param><key>size</key><value>int(frame_len*samp_rate)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>.9</value></param>
<param><key>tr_tag</key><value>BCH</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"channel"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"gate"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>UL SN</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>UL BS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0</value></param>
<param><key>stream_id</key><value>PER 1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_2</value></param>
<param><key>stream_id</key><value>PER 2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>channel_ulcch</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>channel_dlcch</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>UL SN</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>UL BS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>PER 1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>PER 3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>PER 4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>PER 2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>UL SN</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>channel_dlcch</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>channel_ulcch</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://*:5560</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>tcp://*:5562</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://localhost:5559</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>tcp://localhost:5561</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>pdus</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>hier_sensor_0_2</sink_block_id><source_key>pdus</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_easy_upper_0</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>inst</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>ephyl_easy_upper_0</source_block_id><sink_block_id>hier_sensor_0_2</sink_block_id><source_key>inst</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>ephyl_easy_upper_0_0</source_block_id><sink_block_id>hier_bs_0</sink_block_id><source_key>inst</source_key><sink_key>inst</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>BCH</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>DL</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>DLCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>ephyl_easy_upper_0_0</sink_block_id><source_key>feedback</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>hier_bs_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>ULCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>ephyl_easy_upper_0</sink_block_id><source_key>feedback</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>hier_sensor_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_0_2</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0_2</source_block_id><sink_block_id>virtual_sink_0_1_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_sensor_0_2</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>ULCCH</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>hier_sensor_0_2</source_block_id><sink_block_id>ephyl_easy_upper_0</sink_block_id><source_key>feedback</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>hier_sensor_0_2</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>feedback</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>hier_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>out</source_key><sink_key>DLCCH</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>hier_sensor_0_2</sink_block_id><source_key>out</source_key><sink_key>DLCCH</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>hier_bs_0</sink_block_id><source_key>out</source_key><sink_key>ULCCH</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>hier_sensor_0</sink_block_id><source_key>out</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>hier_sensor_0_2</sink_block_id><source_key>out</source_key><sink_key>Inst</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>hier_bs_0</sink_block_id><source_key>out</source_key><sink_key>inst</sink_key></connection>
</flow_graph>
