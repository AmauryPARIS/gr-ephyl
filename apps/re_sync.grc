<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_synchro_fine</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test de re-synchronisation fine</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>MTU*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79,109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Processing duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>UHD</value></param>
<param><key>label</key><value>Over the air</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/root/BS_carrier_complex_2_32b</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>M</value></param>
<param><key>n</key><value>int(M*(1+cp_ratio))</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>int(cp_ratio*M)</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>M*2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>burst</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>M</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>burst</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>M</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(10)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>debug_log</value></param>
<param><key>label</key><value>Generate debug/log files</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_1</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>comment</key><value>Correlates with access code to extract the payload.</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>burst</value></param>
<param><key>threshold</key><value>20</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>2*3.14/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>[-1, 1]</value></param>
</block>
<block>
<key>ephyl_tag_2_msg_char</key>
<param><key>id</key><value>ephyl_tag_2_msg_char_0</value></param>
<param><key>wanted_tag</key><value>"FRAME"</value></param>
</block>
<block>
<key>ephyl_tag_2_msg_char</key>
<param><key>id</key><value>ephyl_tag_2_msg_char_0_0</value></param>
<param><key>wanted_tag</key><value>'PUSCH'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>exit_frame</value></param>
<param><key>label</key><value>Exit Frame</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_1</value></param>
<param><key>decoder_list</key><value>dec_cc</value></param>
<param><key>lentagname</key><value>burst</value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>M</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>list_sensor</value></param>
<param><key>label</key><value>List of sensors</value></param>
<param><key>value</key><value>["A","B"]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>power_tresh_detection</value></param>
<param><key>label</key><value>Treshold value for power detection</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_1</value></param>
<param><key>stream_id</key><value>packet_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2_1</value></param>
<param><key>stream_id</key><value>packet_rx</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>fec_extended_tagged_decoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>virtual_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_1</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_char_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>slot_msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_char_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>slot_msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_1</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_1</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_1</source_block_id><sink_block_id>ephyl_tag_2_msg_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_1</source_block_id><sink_block_id>ephyl_tag_2_msg_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
